# Keil uVision project ATT_Cellular_Mobile_Life_IOT.uvprojx, settings and files
target ATT_Cellular_Mobile_Life_IOT (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.pdsc
  output: ATT_Cellular_Mobile_Life_IOT
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DARM_MATH_CM4 -Otime -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DMBED_BUILD_TIMESTAMP=1486601091.6 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_PORTIN=1 -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -DFSL_RTOS_MBED --md -DTARGET_FRDM -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_K64F -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -D__MBED_CMSIS_RTOS_CM
  c include: .; FXOS8700CQ; MODSERIAL; MODSERIAL/Device; mbed/.; mbed/TARGET_K64F; mbed/TARGET_K64F/TARGET_Freescale; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/TARGET_FRDM; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/drivers; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/api; mbed/TARGET_K64F/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/MK64FN1M0xxx12.sct
  group 
    ./: mbed_config.h HTS221.h cell_modem.h config_me.h hardware.h itm_output.h sensors.h wnc_control.h xadow_gps.h cell_modem.cpp hts221_driver.cpp itm_output.cpp main.cpp sensors.cpp wnc_control.cpp xadow_gps.cpp
  group MODSERIAL
    MODSERIAL/: MACROS.h MODSERIAL.h ChangeLog.c FLUSH.cpp GETC.cpp INIT.cpp ISR_RX.cpp ISR_TX.cpp MODSERIAL.cpp MODSERIAL_IRQ_INFO.cpp PUTC.cpp RESIZE.cpp example1.cpp example2.cpp example3a.cpp example3b.cpp
  group FXOS8700CQ
    FXOS8700CQ/: FXOS8700CQ.h FXOS8700CQ.cpp
  group drivers
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/drivers/: fsl_adc16.h fsl_clock.h fsl_cmp.h fsl_cmt.h fsl_common.h fsl_crc.h fsl_dac.h fsl_dmamux.h fsl_dspi.h fsl_dspi_edma.h fsl_edma.h fsl_enet.h fsl_ewm.h fsl_flash.h fsl_flexbus.h fsl_flexcan.h fsl_ftm.h fsl_gpio.h fsl_i2c.h fsl_i2c_edma.h fsl_llwu.h fsl_lptmr.h fsl_mpu.h fsl_pdb.h fsl_pit.h fsl_pmc.h fsl_port.h fsl_rcm.h fsl_rnga.h fsl_rtc.h fsl_sai.h fsl_sai_edma.h fsl_sdhc.h fsl_sim.h fsl_smc.h fsl_uart.h fsl_uart_edma.h fsl_vref.h fsl_wdog.h
  group api
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/api/: PeripheralPins.h PortNames.h gpio_object.h objects.h
  group TARGET_K64F
    mbed/TARGET_K64F/: MK64F12.h MK64F12_features.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h fsl_device_registers.h system_MK64F12.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/: peripheral_clock_defines.h
  group Device
    MODSERIAL/Device/: AddingDevice.h MODSERIAL_KL05Z.h MODSERIAL_KL25Z.h MODSERIAL_KSDK.h MODSERIAL_LPC11U24.h MODSERIAL_LPC1768.h MODSERIAL_NUCLEO_F401RE.h MODSERIAL_PAC_F401RB.h MODSERIAL_KL05Z.cpp MODSERIAL_KL25Z.cpp MODSERIAL_KSDK.cpp MODSERIAL_LPC11U24.cpp MODSERIAL_LPC1768.cpp MODSERIAL_NUCLEO_F401RE.cpp MODSERIAL_PAC_F401RB.cpp
  group TARGET_FRDM
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_K64F/TARGET_FRDM/: PeripheralNames.h PinNames.h crc.h device.h fsl_clock_config.h fsl_phy.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed_overrides.o retarget.o startup_MK64F12.o sys.o system_MK64F12.o mbed.ar
  group mbed
    mbed/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h CThunk.h CallChain.h Callback.h CircularBuffer.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Driver_Common.h Driver_Storage.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h Transaction.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h critical.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h toolchain.h us_ticker_api.h wait_api.h
